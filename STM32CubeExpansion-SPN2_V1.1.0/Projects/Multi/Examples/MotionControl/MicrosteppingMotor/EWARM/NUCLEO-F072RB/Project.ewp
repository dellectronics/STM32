# IAR project Project.ewp, settings and files
configuration STM32F072RB-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072RB ST STM32F072RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F072xB
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\Inc\NUCLEO-F072RB; ..\..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\..\..\..\Drivers\BSP\Components\L6470; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\..\Drivers\BSP\STM32F0xx-Nucleo; ..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM02A1; ..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM02A1\NUCLEO-F072RB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project Configuration.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP/Components/Common
    ../../../../../../../Drivers/BSP/Components/Common/: microstepping_motor.h
  group Drivers/BSP/Components/L6470
    ../../../../../../../Drivers/BSP/Components/L6470/: L6470.c L6470.h
  group Drivers/BSP/STM32F0xx-Nucleo
    ../../../../../../../Drivers/BSP/STM32F0xx-Nucleo/: stm32f0xx_nucleo.c stm32f0xx_nucleo.h
  group Drivers/BSP/X-NUCLEO-IHM02A1
    ../../../../../../../Drivers/BSP/X-NUCLEO-IHM02A1/: xnucleoihm02a1.c xnucleoihm02a1.h
    ../../../../../../../Drivers/BSP/X-NUCLEO-IHM02A1/NUCLEO-F072RB/: xnucleoihm02a1_interface.c xnucleoihm02a1_interface.h
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Example/EWARM
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f072xb.s
  group Example/User/Inc
    ../../Inc/: example.h example_usart.h params.h
    ../../Inc/NUCLEO-F072RB/: stm32f0xx_hal_conf.h stm32f0xx_it.h
  group Example/User/Src
    ../../Src/: example.c example_usart.c main.c params.c
    ../../Src/NUCLEO-F072RB/: stm32f0xx_hal_msp.c stm32f0xx_it.c
