# Keil uVision project Project.uvprojx, settings and files
target STM32F072RB-Nucleo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F072RB-Nucleo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=$l@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c misc: --C99
  c include: ..\..\Inc;..\..\Inc\NUCLEO-F072RB;..\..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\..\..\..\..\Drivers\BSP\Components\L6470;..\..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\..\Drivers\BSP\STM32F0xx-Nucleo;..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM02A1;..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM02A1\NUCLEO-F072RB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/X-NUCLEO-IHM02A1
    ../../../../../../../Drivers/BSP/X-NUCLEO-IHM02A1/NUCLEO-F072RB/: xnucleoihm02a1_interface.c xnucleoihm02a1_interface.h
    ../../../../../../../Drivers/BSP/X-NUCLEO-IHM02A1/: xnucleoihm02a1.h xnucleoihm02a1.c
  group Drivers/BSP/Components/Common
    ../../../../../../../Drivers/BSP/Components/Common/: microstepping_motor.h
  group Example/User/Inc
    ../../Inc/NUCLEO-F072RB/: stm32f0xx_hal_conf.h stm32f0xx_it.h
    ../../Inc/: example.h params.h example_usart.h
  group Drivers/BSP/Components/L6470
    ../../../../../../../Drivers/BSP/Components/L6470/: L6470.h L6470.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_flash.c stm32f0xx_hal_spi.c stm32f0xx_hal.c stm32f0xx_hal_rcc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c
  group Drivers/BSP/STM32F0xx-Nucleo
    ../../../../../../../Drivers/BSP/STM32F0xx-Nucleo/: stm32f0xx_nucleo.h stm32f0xx_nucleo.c
  group Example/User/Src
    ../../Src/: params.c example.c main.c example_usart.c
    ../../Src/NUCLEO-F072RB/: stm32f0xx_hal_msp.c stm32f0xx_it.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Example/MDK-ARM
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072xb.s
software components: CMSIS:CORE 3.40.0
