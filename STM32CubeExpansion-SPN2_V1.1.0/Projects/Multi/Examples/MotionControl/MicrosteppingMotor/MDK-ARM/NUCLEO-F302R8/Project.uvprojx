# Keil uVision project Project.uvprojx, settings and files
target STM32F302R8-Nucleo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F302R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F302R8-Nucleo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=$l@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F302x8
  c misc: --C99
  c include: ..\..\Inc;..\..\Inc\NUCLEO-F302R8;..\..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\..\..\..\Drivers\BSP\Components\L6470;..\..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\..\Drivers\BSP\STM32F3xx-Nucleo;..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM02A1;..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM02A1\NUCLEO-F302R8
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_dma.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_spi.c stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_uart.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rcc.c
  group Example/MDK-ARM
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/arm/: startup_stm32f302x8.s
  group Drivers/BSP/Components/L6470
    ../../../../../../../Drivers/BSP/Components/L6470/: L6470.c L6470.h
  group Drivers/BSP/STM32F3xx-Nucleo
    ../../../../../../../Drivers/BSP/STM32F3xx-Nucleo/: stm32f3xx_nucleo.c stm32f3xx_nucleo.h
  group Drivers/BSP/X-NUCLEO-IHM02A1
    ../../../../../../../Drivers/BSP/X-NUCLEO-IHM02A1/: xnucleoihm02a1.h xnucleoihm02a1.c
    ../../../../../../../Drivers/BSP/X-NUCLEO-IHM02A1/NUCLEO-F302R8/: xnucleoihm02a1_interface.c xnucleoihm02a1_interface.h
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Example/User/Src
    ../../Src/NUCLEO-F302R8/: stm32f3xx_it.c stm32f3xx_hal_msp.c
    ../../Src/: main.c params.c example.c example_usart.c
  group Drivers/BSP/Components/Common
    ../../../../../../../Drivers/BSP/Components/Common/: microstepping_motor.h
  group Example/User/Inc
    ../../Inc/NUCLEO-F302R8/: stm32f3xx_hal_conf.h stm32f3xx_it.h
    ../../Inc/: example.h params.h example_usart.h
software components: CMSIS:CORE 3.40.0
