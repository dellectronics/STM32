# Keil uVision project Project.uvprojx, settings and files
target STM32F401RE-Nucleo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F401RE-Nucleo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=$l@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE
  c misc: --C99
  c include: ..\..\Inc;..\..\Inc\NUCLEO-F401RE;..\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\..\Drivers\BSP\Components\L6470;..\..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM02A1;..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM02A1\NUCLEO-F401RE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/Component/L6470
    ../../../../../../../Drivers/BSP/Components/L6470/: L6470.c L6470.h
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_adc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c
  group Drivers/BSP/Component/Common
    ../../../../../../../Drivers/BSP/Components/Common/: microstepping_motor.h
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c stm32f4xx_nucleo.h
  group Drivers/BSP/X-NUCLEO-IHM02A1
    ../../../../../../../Drivers/BSP/X-NUCLEO-IHM02A1/: xnucleoihm02a1.c xnucleoihm02a1.h
    ../../../../../../../Drivers/BSP/X-NUCLEO-IHM02A1/NUCLEO-F401RE/: xnucleoihm02a1_interface.c xnucleoihm02a1_interface.h
  group Example/User/Src
    ../../Src/NUCLEO-F401RE/: stm32f4xx_hal_msp.c stm32f4xx_it.c
    ../../Src/: example_usart.c example.c main.c params.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Example/User/Inc
    ../../Inc/: example_usart.h example.h params.h
    ../../Inc/NUCLEO-F401RE/: stm32f4xx_hal_conf.h stm32f4xx_it.h
  group Example/MDK-ARM
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xe.s
software components: CMSIS:CORE 3.40.0
